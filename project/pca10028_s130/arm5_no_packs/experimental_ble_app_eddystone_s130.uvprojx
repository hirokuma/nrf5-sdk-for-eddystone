# Keil uVision project experimental_ble_app_eddystone_s130.uvprojx, settings and files
target nrf51822_s130 (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.6.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51822_s130 +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD  BOARD_BVMCNDT52 S130 NRF_LOG_USES_RTT=0 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  c include: ..\config;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_ext\segger_rtt;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s130\headers;..\..\..\..\..\..\components\softdevice\s130\headers\nrf51;..\..\..\..\..\..\components\toolchain;..\..\..\bsp;..\..\..\include\ble_services;..\..\..\include\modules;..\..\..\include\def;..\..\..\include\config;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\include\util;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\bsp\;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\source\crypto_libs\cifra;..\..\..\source\crypto_libs\rfc6234;..\..\..\source\crypto_libs\;..\..\..\..\..\..\components\libraries\fstorage\config
  asm define: BLE_STACK_SUPPORT_REQD BOARD_BVMCNDT52 S130 NRF_LOG_USES_UART=0 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20002000 size 0x4000
  group Application
    ../: main.c
  group Board Support
    ../../../../../bsp/: bsp.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
  group nRF_Drivers
    ../../../../../../components/libraries/uart/: app_uart.c
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c nrf_log.c app_error_weak.c app_util_platform.c
    ../../../../../../components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../../../../../components/libraries/uart/: retarget.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/fstorage/: fstorage.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group BLE_Services
    ../../../source/ble_services/: ble_ecs.c
  group Modules
    ../../../source/modules/: eddystone_ble_handler.c eddystone_adv_slot.c eddystone_security.c eddystone_registration_ui.c eddystone_flash.c eddystone_advertising_manager.c eddystone_tlm_manager.c
  group cifra
    ../../../source/crypto_libs/cifra/: blockwise.c cbcmac.c chash.c cmac.c curve25519.donna.c drbg.c eax.c gf128.c hmac.c modes.c sha1.c sha256.c aes.c
  group rfc6234
    ../../../source/crypto_libs/rfc6234/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
  group tiny-aes128-c
    ../../../source/crypto_libs/tiny-aes128-c/: aes.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.6.0
